options:
  parameters:
    generate_options: qt_gui
    id: nrf24_receiver
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '5e-4'
    gate: 'False'
    ramp: '0'
    threshold: '-40'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1.5707/(samp_rate/symbol_rate)
  states: {state: disabled}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/herve/Documents/gr-nordic/examples/nrf_data.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: (samp_rate/symbol_rate)*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {state: disabled}
- name: digital_gfsk_demod_1
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(samp_rate/symbol_rate)
    sensitivity: 1.5707/(samp_rate/symbol_rate)
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1'
    loop_bw: 2*numpy.pi/70
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: int(samp_rate/symbol_rate)
    ted_gain: '1'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2520000000'
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.2e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 250e3
    win: window.WIN_HAMMING
  states: {}
- name: nordic_nordic_rx_0
  id: nordic_nordic_rx
  parameters:
    address_length: '5'
    channel: '120'
    crc_length: '2'
    data_rate: '2'
  states: {}
- name: nordic_nordictap_printer_0
  id: nordic_nordictap_printer
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: 8192*16
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"squelch_sob"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '256'
    srate: samp_rate/2
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '256'
    srate: samp_rate/(samp_rate/symbol_rate)
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: 2e6
    center_freq0: '2520000000'
    dev_args: '""'
    gain0: '60'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', low_pass_filter_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_1, '0']
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_char_to_float_2, '0', qtgui_time_sink_x_2_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', analog_pwr_squelch_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', nordic_nordic_rx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_2_0, '0']
- [digital_gfsk_demod_1, '0', blocks_char_to_float_2, '0']
- [digital_gfsk_demod_1, '0', nordic_nordic_rx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_2_0, '0']
- [iio_pluto_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', digital_gfsk_demod_1, '0']
- [nordic_nordic_rx_0, nordictap_out, nordic_nordictap_printer_0, nordictap_in]
- [uhd_usrp_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
